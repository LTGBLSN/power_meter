# Keil uVision project GPIO.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: GPIO +hex
  c flags: SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\Code\HX711;.\Code\KEY;.\Code\ADC;.\Code\DS18B20
  group Source Group 1
    ./Code/: GPIO.C
  group Common
    ./Common/: Common.c Delay.c
    ./Code/: IIC_INA226.c INA226_APP.c oled.c
  group Startup
    ./Startup/: STARTUP.A51
